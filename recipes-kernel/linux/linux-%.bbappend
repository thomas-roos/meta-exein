# Always enable BTF support required by Exein Photon eBPF LSM
require ${BPN}_btf.inc
